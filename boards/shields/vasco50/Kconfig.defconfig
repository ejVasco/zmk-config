## boards/shields/vasco50/Kconfig.defconfig
```kconfig
if SHIELD_VASCO50

config ZMK_KEYBOARD_NAME
    default "vasco50"

endif # SHIELD_VASCO50
```
